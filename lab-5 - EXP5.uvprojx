# Keil uVision project lab-5 - EXP5.uvprojx, settings and files
target Lab-1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: _lab-1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: .\Board;.\Core;.\Fw_lib\inc;.\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Fw_lib
    ./Fw_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Core
    ./Core/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Board
    ./Board/: IERG3810_Buzzer.c IERG3810_clock.c IERG3810_KEY.c IERG3810_LED.c IERG3810_USART_PRINT.c IERG3810_USART1.c IERG3810_USART2.c IERG3810_TFTLCD.c IERG3810_Delay.c IERG3810_INTERRUPT.c IERG3810_TIMER.c IERG3810_MINI.c IERG3810_MINI_LENGTH.h IERG3810_MINI_MAP.H IERG3810_MINI_MAP_IV.h IERG3810_MINI_IMAGE.h IERG3810_MINI_MAP_III.h IERG3810_MINI_TABLE_BRIEF.H IERG3810_MINI_TABLE_FULL.H FONT.H
  group User
    ./User/: stm32f10x_it.c main.c
